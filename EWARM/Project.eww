<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\WB55_HSE_CALIB_RTT.ewp</path>
  </project>
  <batchBuild />
</workspace>
